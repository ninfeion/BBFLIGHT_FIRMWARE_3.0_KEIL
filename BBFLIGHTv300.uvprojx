# Keil uVision project BBFLIGHTv300.uvprojx, settings and files
target BBFLIGHTv300 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: BBFLIGHTv300 +hex
  c flags: Optim=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\User\inc;.\User\USB\inc;.\User\USB\STM32_USB-FS-Device_Driver\inc;.\User\DMP\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c system_config.h
    ./User/src/: control.c imucal_px.c system_loop.c systeminit.c
  group Driver
    ./User/src/: adc.c delay.c filter.c i2c.c mpu9250.c ms5611.c pwm.c spinrf.c usb2com.c
  group USB_CDC
    ./User/USB/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_it.c Queue.c
  group USB_StdDrivers
    ./User/USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group ::Device
    C:/Extra Software/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.0.0/Device/StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_exti.c misc.c stm32f10x_dma.c
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s system_stm32f10x.c stm32f10x_conf.h
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
